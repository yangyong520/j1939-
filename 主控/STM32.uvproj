# Keil uVision project STM32.uvproj, settings and files
target STM32_USART1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32 +hex
  c flags: Optim=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: .\FWlib\inc;.\user;.\user\usart;.\user\CAN;.\j1939
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_cl.s
  group User
    ./user/: main.c stm32f10x_it.c
    ./user/usart/: usart.c
    ./user/CAN/: CAN.c
    ./j1939/: J1939.c J1939.H J1939_Config.H
  group StdPeriph_Drive
    ./FWlib/SRC/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_flash.c
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
